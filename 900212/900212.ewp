# IAR project 900212.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCDefines: ENABLE_BIT_DEFINITIONS
  ICCAVR.newCCIncludePaths: ..\SRC; ..\VSAPI; ..\VSSRC
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration Release (AVR)
  as the first configuration, except:
  group src
    src/: defs.h DeviceSetup.c eventHandler.h generic.c globals.h init.c inputs.c simpleEventHandler.c simpleEventHandler.h timers.c usart2.c usart2.h userloop.c VSActionToOutput.c VSMain.c VSMain.h
  group vsapi
    vsapi/: RealLink.c SEMLibB.c
  group vssrc
    vssrc/: System1.c System1Data.c
