# IAR project ewide.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group Common
    ew/src/: defs.h DeviceSetup.c eventHandler.h generic.c globals.h init.c inputs.c simpleEventHandler.c simpleEventHandler.h timers.c usart2.c usart2.h userloop.c VSActionToOutput.c VSMain.c VSMain.h
    ew/vsapi/: RealLink.c RealLink.h SEMLibB.c SEMLibB.h VSTypes.h
    ew/vssrc/: SEMBDef.h SEMTypes.h System1.c System1.h System1Action.h System1Data.c System1Data.h
