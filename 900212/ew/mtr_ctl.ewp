# IAR project mtr_ctl.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x80
  General.SCRStackSize: 16
  ICCAVR.newCCIncludePaths: M:\VisualState\ProjectM16Motor\ew\src\; M:\VisualState\ProjectM16Motor\ew\vssrc\; M:\VisualState\ProjectM16Motor\ew\vsapi\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration RealLinkDebug (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x40
  ICCAVR.CCDefines: VS_IS_EXPERT=0
  ICCAVR.newCCIncludePaths: VSSRC; VSAPI
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfg8515.xcl
configuration release (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x40
  ICCAVR.newCCIncludePaths: VSSRC; VSAPI
  group RealLink
    vsapi/: RealLink.c
    vssrc/: VSrlps.c
  group Src
    src/: DeviceSetup.c generic.c init.c inputs.c simpleEventHandler.c timers.c usart2.c userloop.c VSActionToOutput.c VSMain.c
  group VSAPI
    vsapi/: SEMLibB.c
  group VSSrc
    vssrc/: System1.c System1Data.c
